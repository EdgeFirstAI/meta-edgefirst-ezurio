# A vendored patch in meta-imx-bsp lacks the Upstream-Status tag, which trips
# the patch-status QA check.
ERROR_QA:remove = "patch-status"
